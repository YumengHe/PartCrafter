Commit message: fix error

File: URDFoptimizer/input/mobility_optimized.urdf (robot description, URDF)
Before this commit: robot partnet_10798ccb7072393e86d53ab0fe94e911, 3 links, 2 joints
Joints:
- joint joint_0: origin xyz=0.13644283 0.03056186 -0.37981406 -> xyz=0.18202803 0.00000000 0.20976162
